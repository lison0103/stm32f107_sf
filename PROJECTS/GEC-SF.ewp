# IAR project GEC-SF.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_USB_OTG_FS; GEC_SF_MASTER; EWARMv5
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Libraries\CMSIS; ..\Libraries\STM32_ETH_Driver\inc; ..\Libraries\STM32_USB_Device_Library\Class\cdc\inc; ..\Libraries\STM32_USB_Device_Library\Core\inc; ..\Libraries\STM32_USB_OTG_Driver\inc; ..\App; ..\FATFS\src; ..\FATFS\exfuns; ..\SYSTEM; ..\HARDWARE\LED; ..\HARDWARE\MB85RCXX; ..\HARDWARE\EWDT; ..\HARDWARE\CAN; ..\HARDWARE\SPI; ..\HARDWARE\TIMER; ..\HARDWARE\EXTI; ..\HARDWARE\USART; ..\MALLOC; ..\VCP\inc; ..\SELFTEST\inc; ..\ESC\inc; ..\SELFTEST\SelfTestLib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GEC-SF.hex
  ILINK.IlinkOutputFile: GEC-SF.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
configuration GEC-SF-M (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: GEC-SF-M.hex
  ILINK.IlinkOutputFile: GEC-SF-M.out
  ILINK.IlinkIcfFile: GEC-SF-M_flash.icf
configuration GEC-SF-S (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  OBJCOPY.OOCOutputFile: GEC-SF-S.hex
  ILINK.IlinkOutputFile: GEC-SF-S.out
  ILINK.IlinkIcfFile: GEC-SF-S_flash.icf
  group APP
    ../APP/: bsp_iocfg.c crc16.c hw_test.c initial_devices.c self_test.c
    ../VCP/src/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
  group ESC
    ../ESC/src/: esc_comm_db.c esc_error_process.c esc_record_data.c
  group FWLib/CMSIS
    ../Libraries/CMSIS/: system_stm32f10x.c
  group FWLib/CMSIS/Starup
    ../Libraries/CMSIS/startup/: startup_stm32f10x_cl.s
  group FWLib/SRC
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/EWDT/: ewdt.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/MB85RCXX/: mb85rcxx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/USART/: usart.c
  group SELFTEST
    ../SELFTEST/src/: check_instruction.c check_instruction_post.s check_instruction_post_2.s clock_test.c config_test.c cpu_reg_test.c cpu_reg_test_post.s flag_test.c flash_test.c pc_test.c ram_test.c wdt_test.c
    ../SELFTEST/SelfTestLib/: stm32f10x_STLclockrun.c stm32f10x_STLclockstart.c stm32f10x_STLcpustartIARv5.s stm32f10x_STLcrc16.c stm32f10x_STLcrc16Run.c stm32f10x_STLcrc32.c stm32f10x_STLmain.c stm32f10x_STLstartup.c
  group SELFTEST/inc
    ../SELFTEST/inc/: check_instruction.h check_instruction_2.h clock_test.h config_test.h cpu_reg_test.h flag_test.h flash_test.h iec61508.h pc_test.h ram_test.h stack_test.h wdt_test.h
    ../SELFTEST/SelfTestLib/: stm32f10x_STLclockstart.h stm32f10x_STLparam.h
  group SYSTEM
    ../SYSTEM/: delay.c sys.c
  group USB/Class/CDC
    ../Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core_loopback.c
  group USB/Core
    ../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB/Driver
    ../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USER
    ./: main.c stm32f10x_conf.h stm32f10x_it.c
