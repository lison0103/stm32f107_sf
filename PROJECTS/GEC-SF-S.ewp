# IAR project GEC-SF-S.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Libraries\CMSIS; ..\App; ..\SYSTEM; ..\HARDWARE\LED; ..\HARDWARE\EWDT; ..\HARDWARE\CAN; ..\HARDWARE\SPI; ..\HARDWARE\EXTI; ..\HARDWARE\TIMER; ..\SELFTEST\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GEC-SF-S.hex
  ILINK.IlinkOutputFile: GEC-SF-S.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../APP/: hw_test.c self_test.c
  group FWLib/CMSIS
    ../Libraries/CMSIS/: system_stm32f10x.c
  group FWLib/CMSIS/Starup
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group FWLib/SRC
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/EWDT/: ewdt.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TIMER/: timer.c
  group SELFTEST
    ../SELFTEST/src/: check_instruction.c check_instruction_post.s check_instruction_post_2.s clock_test.c config_test.c cpu_reg_test.c cpu_reg_test_post.s flag_test.c flash_test.c pc_test.c ram_test.c wdt_test.c
  group SELFTEST/inc
    ../SELFTEST/inc/: check_instruction.h check_instruction_2.h clock_test.h config_test.h cpu_reg_test.h flag_test.h flash_test.h iec61508.h pc_test.h ram_test.h stack_test.h wdt_test.h
  group SYSTEM
    ../SYSTEM/: delay.c sys.c
  group USER
    ./: main.c stm32f10x_conf.h stm32f10x_it.c
