# IAR project stm32f107.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Libraries\CMSIS; ..\Libraries\STM32_ETH_Driver\inc; ..\Libraries\STM32_USB_Device_Library\Class\msc\inc; ..\Libraries\STM32_USB_Device_Library\Core\inc; ..\Libraries\STM32_USB_OTG_Driver\inc; ..\App; ..\FATFS\src; ..\FATFS\exfuns; ..\SYSTEM; ..\HARDWARE\LED; ..\HARDWARE\MB85RCXX; ..\HARDWARE\EWDT; ..\HARDWARE\SPI; ..\MALLOC
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32f107.hex
  ILINK.IlinkOutputFile: stm32f107.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../APP/: usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
  group FWLib/CMSIS
    ../Libraries/CMSIS/startup/: startup_stm32f10x_cl.s
    ../Libraries/CMSIS/: system_stm32f10x.c
  group FWLib/SRC
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/EWDT/: ewdt.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/MB85RCXX/: mb85rcxx.c
    ../HARDWARE/SPI/: spi.c
  group MALLOC
    ../MALLOC/: malloc.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart.c
  group USB Device/Class/MSC
    ../Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB Device/Library
    ../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB Drivers
    ../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USER
    ../APP/: main.c
    ./: stm32f10x_conf.h stm32f10x_it.c
