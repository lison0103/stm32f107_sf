# IAR project Backup of GEC-SF.ewp, settings and files
configuration GEC-SF-M (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_USB_OTG_FS; GEC_SF_MASTER; EWARMv5
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Libraries\CMSIS; ..\Libraries\STM32_ETH_Driver\inc; ..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc; ..\Libraries\STM32_USB_HOST_Library\Core\inc; ..\Libraries\STM32_USB_OTG_Driver\inc; ..\FATFS\src; ..\FATFS\exfuns; ..\HARDWARE\LED; ..\HARDWARE\MB85RCXX; ..\HARDWARE\EWDT; ..\HARDWARE\CAN; ..\HARDWARE\SPI; ..\HARDWARE\TIMER; ..\HARDWARE\EXTI; ..\HARDWARE\USART; ..\MALLOC; ..\ESC\inc; ..\SAFETYTEST\SelfTestLib; ..\SAFETYTEST\; ..\BSP; ..\HARDWARE\ADC; ..\USB\USB_MASS_STORAGE\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GEC-SF-M.hex
  ILINK.IlinkOutputFile: GEC-SF-M.out
  ILINK.IlinkIcfFile: GEC-SF-M_flash.icf
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GEC-SF-S (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; EWARMv5
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Libraries\CMSIS; ..\Libraries\STM32_ETH_Driver\inc; ..\Libraries\STM32_USB_Device_Library\Class\cdc\inc; ..\Libraries\STM32_USB_Device_Library\Core\inc; ..\Libraries\STM32_USB_OTG_Driver\inc; ..\BSP; ..\FATFS\src; ..\FATFS\exfuns; ..\HARDWARE\LED; ..\HARDWARE\MB85RCXX; ..\HARDWARE\EWDT; ..\HARDWARE\CAN; ..\HARDWARE\SPI; ..\HARDWARE\TIMER; ..\HARDWARE\EXTI; ..\HARDWARE\USART; ..\MALLOC; ..\VCP\inc; ..\ESC\inc; ..\SAFETYTEST\SelfTestLib; ..\SAFETYTEST\
  OBJCOPY.OOCOutputFile: GEC-SF-S.hex
  ILINK.IlinkOutputFile: GEC-SF-S.out
  ILINK.IlinkIcfFile: GEC-SF-S_flash.icf
configuration GEC-SF-S-NEW (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F302xB ST STM32F302xB
  General.CoreVariant: 39
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F30X; EWARMv5; GEC_SF_S_NEW; USE_STM32303C_EVAL
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\Libraries\STM32F30x_StdPeriph_Driver\inc; ..\Libraries\CMSIS; ..\Libraries\STM32_ETH_Driver\inc; ..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\Libraries\STM32_USB_OTG_Driver\inc; ..\BSP; ..\FATFS\src; ..\FATFS\exfuns; ..\HARDWARE\LED; ..\HARDWARE\MB85RCXX; ..\HARDWARE\EWDT; ..\HARDWARE\CAN; ..\HARDWARE\SPI; ..\HARDWARE\TIMER; ..\HARDWARE\EXTI; ..\HARDWARE\USART; ..\MALLOC; ..\VCP\inc; ..\ESC\inc; ..\SAFETYTEST\SelfTestLib; ..\SAFETYTEST\; ..\USB\USB_Virtual_COM_Port\inc
  OBJCOPY.OOCOutputFile: GEC-SF-S.hex
  ILINK.IlinkOutputFile: GEC-SF-S.out
  ILINK.IlinkIcfFile: GEC-SF-S-NEW_flash.icf
  group BSP
    ../BSP/: bsp_input.c bsp_iocfg.c crc16.c delay.c fatfs.c hw_test.c initial_devices.c safety_test.c sys.c
  group ESC
    ../ESC/inc/: esc.h
    ../ESC/src/: esc_cmd_state.c esc_comm_control.c esc_comm_diagnostic.c esc_comm_safety_dualcpu.c esc_error_process.c esc_handrail_speed.c esc_interrupt.c esc_missing_step.c esc_motor_speed.c esc_parameter_process.c esc_record_data.c esc_safety_check.c esc_tandem.c
  group FATFS
    ../FATFS/src/option/: ccsbcs.c
    ../FATFS/src/: diskio.c ff.c
  group FWLib/CMSIS
    ../Libraries/CMSIS/: system_stm32f10x.c system_stm32f30x.c
  group FWLib/CMSIS/Starup
    ../Libraries/CMSIS/startup/: startup_stm32f10x_cl.s startup_stm32f10x_md.s startup_stm32f30x.s
  group FWLib/STM32F10X_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FWLib/STM32F30X_StdPeriph_Driver
    ../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_fmc.c stm32f30x_gpio.c stm32f30x_hrtim.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/EWDT/: ewdt.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/MB85RCXX/: mb85rcxx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/USART/: usart.c
  group MALLOC
    ../MALLOC/: malloc.c
  group SafetyTest
    ../SAFETYTEST/: check_instruction.c check_instruction_post.s check_instruction_post_2.s config_test.c flag_test.c pc_test.c
  group SafetyTest/SelfTestLib
    ../SAFETYTEST/SelfTestLib/: stm32f10x_STLclockrun.c stm32f10x_STLclockstart.c stm32f10x_STLcpurunIARv5.s stm32f10x_STLcpustartIARv5.s stm32f10x_STLcrc16.c stm32f10x_STLcrc16Run.c stm32f10x_STLcrc32.c stm32f10x_STLcrc32Run.c stm32f10x_STLfullRamMc.c stm32f10x_STLmain.c stm32f10x_STLparam.h stm32f10x_STLstartup.c stm32f10x_STLtranspRamMc.c stm32f10x_STLtranspRamMx.c
  group USB/USB_DEVICE_VCP
    ../USB/USB_Virtual_COM_Port/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_virtual_com_port.c
  group USB/USB_DEVICE_VCP/Driver
    ../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB/USB_HOST_MSC
    ../USB/USB_MASS_STORAGE/src/: usb_bsp.c usb_func.c usbh_usr.c
  group USB/USB_HOST_MSC/Class/MSC
    ../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group USB/USB_HOST_MSC/Core
    ../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group USB/USB_HOST_MSC/Driver
    ../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group USER
    ./: main.c stm32f10x_conf.h stm32f10x_it.c stm32f30x_conf.h stm32f30x_it.c
